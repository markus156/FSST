# Keil uVision project Proc Vis.uvproj, settings and files
target mbed NXP LPC11U24 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: xx2
  AfterMake: C:\Keil\ARM\BIN\ElfDwT.exe  !L
  AfterMake: fromelf --bin -o @L.bin !L
  c flags: Optim=1
  c define: TARGET_LPC11U24,  TARGET_M0,  TARGET_NXP,  TARGET_LPC11UXX,  TARGET_LPC11U24_401,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1396801409.8,  __MBED__=1,
  c misc: --gnu
  c include: .;..\..\Lib\inc;..\..\Lib\mbed;..\..\Lib\HL
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: ../../Lib/mbed/LPC11U24.sct
  link misc: ../../Lib/mbed/system_LPC11Uxx.o  
../../Lib/mbed/sys.o  
../../Lib/mbed/cmsis_nvic.o    
../../Lib/mbed/startup_LPC11xx.o   
../../Lib/mbed/core_cm0.o   
../../Lib/mbed/mbed.ar
  group src
    ../../Lib/HL/: Serial_HL.cpp Bertl14.cpp
    ./: FuncGenMain3.cpp FuncGenFSST2.cpp FuncGenFSST2.h Tp1Ord.cpp Tp1Ord.h
